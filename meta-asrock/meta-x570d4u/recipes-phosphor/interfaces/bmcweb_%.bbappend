FILESEXTRAPATHS:prepend := "${THISDIR}/bmcweb:"

SRC_URI += "file://0001-host-interface-tls.patch \
            file://0002-host-interface-uploads.patch"
