RDEPENDS:${PN}-system:append = " phosphor-sel-logger host-interface x570d4u-fan-control x570d4u-uid-led"
